# Keil uVision project USER.uvprojx, settings and files
target MCUSPI2 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: thefirstest +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10X_FWLlib\inc;..\SYSYTEM\sys;..\SYSYTEM\usart;..\HARDWARE\RTC;..\HARDWARE\SPI1;..\HARDWARE\SPI1WriteRead;..\HARDWARE\SPI2;..\HARDWARE\COMMO;..\DSPlib;..\USER;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\DMA;..\HARDWARE\openin
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10X_FWLlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSYTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/SPI2/: spi2.c
    ../HARDWARE/SPI1/: spi1.c
    ../HARDWARE/SPI1WriteRead/: SPI1WriteRead.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/COMMO/: commo.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/openin/: openin.c
  group DSPlib
    ../DSPlib/: cr4_fft_64_stm32.s stm32_dsp.h table_fft.h fft.c
software components: RTOS:kernel 3.1.3
